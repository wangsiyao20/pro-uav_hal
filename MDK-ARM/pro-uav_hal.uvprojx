# Keil uVision project pro-uav_hal.uvprojx, settings and files
target pro-uav_hal (5060960::V5.06 update 7 (build 960)::.\02_arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: pro-uav_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Mid/FreeRTOS;../Mid/FreeRTOS/include;../Mid/FreeRTOS/portable/RVDS/ARM_CM3;../Angle-MPU_6050/App;../Angle-MPU_6050/Int;../Com/filter;../EleMachine-/App;../EleMachine-/Int;../Battery_Power/App;../Battery_Power/Int;../Pilot_LED/App;../Pilot_LED/Int;../Communi-Si24R1/App;../Communi-Si24R1/Int
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/portable
    ../Mid/FreeRTOS/portable/: heap_4.c
    ../Mid/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/source
    ../Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Mid/FreeRTOS/: FreeRTOSConfig.h
  group Angle-Mpu_6050
    ../Angle-MPU_6050/App/: App_Mpu6050.c App_Mpu6050_Quaternion.c
    ../Angle-MPU_6050/Int/: Int_Mpu6050.c
  group Com
    ../Com/filter/: Com_Filter.c Com_IMU.c Com_Kalman.c
  group EleMachine-PWM
    ../EleMachine-/App/: App_PWM.c
    ../EleMachine-/Int/: Int_PWM.c
  group Battery_Power
    ../Battery_Power/App/: App_Battery.c
    ../Battery_Power/Int/: Int_Battery.c
  group Pilot_LED
    ../Pilot_LED/App/: App_PilotLED.c
    ../Pilot_LED/Int/: Int_PilotLED.c
  group Commu-Si24R1
    ../Communi-Si24R1/App/: App_Si24R1.c
    ../Communi-Si24R1/Int/: Int_Si24R1.c
software components: CMSIS:CORE 4.3.0
